Commit message: Added mapper arm

File: mani_skill/assets/robots/panda/panda_v3.urdf (robot description, URDF)
Before this commit: robot panda, 15 links, 14 joints
Joints:
- joint realsense_joint: origin xyz=0.035 0 0.036 rpy=0 -1.5707 3.1415 -> xyz=0.042 0.0 0.036 rpy=0 -1.8326 3.1415
